# Keil uVision project m1_sampling.uvprojx, settings and files
target m1_sampling (6130001::V6.13.1::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(72000000) CPUTYPE("Cortex-M3") TZ
  output: m1_sampling +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --target=arm-arm-none-eabi -mcpu=cortex-m3 -std=c11 -O2 -Wall -Wextra
  c include: ../Core/Inc;../board;../app;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../control_core
  asm misc: --cpu=Cortex-M3
  library: MicroLIB
  memory RVCT4: ROM 0x08000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: m1_sampling.sct
  link misc: --strict --entry=Reset_Handler
  group Startup
    ../MDK-ARM/: startup_stm32f103xb.s
  group Application
    ../Core/Src/: main.c system_stm32f1xx.c stm32f1xx_it.c adc.c dma.c gpio.c spi.c tim.c usart.c stm32f1xx_hal_msp.c
    ../board/: board_io.c sample_frame.c board_uart.c
    ../app/: motor_runtime.c telemetry.c command.c
    ../../../control_core/: sensor_input.c feedback.c
  group ST HAL
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
